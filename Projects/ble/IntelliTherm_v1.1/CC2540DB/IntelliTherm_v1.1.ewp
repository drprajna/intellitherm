# IAR project IntelliTherm_v1.1.ewp, settings and files
configuration CC2540DK-MINI Keyfob Slave (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540.i51
  ICC8051.CCDefines: INT_HEAP_LEN=2900; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_UART=TRUE; CC2540_MINIDK
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\common\npi\npi_np; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\Thermometer; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2540 Slave (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=2900; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=TRUE; HAL_UART=TRUE
configuration CC2540 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=TRUE; HAL_UART=TRUE; HAL_KEY=TRUE
  ICC8051.CCDiagSuppress: Pa050
  group APP
    ../Source/: _public.c _public.h ADS8326.c ADS8326.h OSAL_thermometer.c thermometer.c thermometer.h thermometer_Main.c timeapp.h timeapp_clock.c timeapp_config.c timeapp_discovery.c timeapp_ind.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/hci/: hci_data.h hci_event.h hci_tl.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/include/: ll.h ll_sleep.h phy.h phy_image.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/Thermometer/: thermometerservice.c thermometerservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
